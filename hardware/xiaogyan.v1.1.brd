# Repository algyan/XIAOGYAN

File README.md:

# XIAOGYAN

IoT ALGYAN 8周年 オリジナルIoTデバイス「XIAOGYAN」のリポジトリです。

IoTをやってみたい人から、バリバリのベテランにも楽しんでもらえるIoTデバイスを目指しています。

* デバイス、ソフトウェア、クラウドの全てにおいて、完成品（クラウドはお試しする場所）を提供するとともに、全てをオープン、カスタマイズ可能に
* 入手しやすい部品（ほぼ全ての部品を秋月電子通商で入手できる）
* 部品代は3000円以内
* 開発PCはWindows, macOS, Linux

ご質問、ご意見は[Discussions](https://github.com/algyan/XIAOGYAN/discussions)や[Issues](https://github.com/algyan/XIAOGYAN/issues)へ。お気軽にどうぞ。

## 構成

```mermaid
flowchart LR
    id1[LEDマトリックス]---id7[LEDドライバ]
    id7-- x2 DO ---id2[マイコン]
    id3[スピーカー]---id11[パワーアンプ]
    id11-- x1 PWM,x1 DO ---id2
    id4[ロータリーエンコーダー]-- x2 DI ---id2
    id8[x1 LED]-- x1 DO ---id2
    id9[x2 ボタン]-- x2 DI ---id2
    id2-- Wi-Fi ---id6[Azure IoT]
    id10[Grove I2C]-- I2C ---id2
```

## マニュアル

* [しおり（手引書）](manuals/guidebook/README.md)
* [部品手配マニュアル](manuals/order/README.md)
* [機材マニュアル](manuals/equipment/README.md)
* [組立マニュアル](manuals/assembly/README.md)
* [動作確認マニュアル](manuals/test/README.md)
* [ソフトウェア開発マニュアル](manuals/software/README.md)

## 事例

* [XIAOGYANやってみたよ！！ユーザー投稿](https://github.com/algyan/XIAOGYAN/discussions/50)
* [XIAOGYANbitLess （XIAOGYANをScratchで使うためのプログラム）](https://github.com/610t/XIAOGYANbitLess)
* [XIAO-ESP32-C3 で AtomVM を動作させたときのメモ](https://gist.github.com/pojiro/ccb9d88dedd0590a8ac6930b37633ee0)
* [XIAOGYANでEagleのグリッド切り替え](https://github.com/lipoyang/GridSwitch)

## リファレンス

* ハードウェア
  * [部品リスト](hardware/xiaogyan.v1.xlsx)
  * [部品貼付台紙](hardware/xiaogyan_pasteboard.v1.pdf)
  * [回路図(v1)](hardware/xiaogyan.v1.pdf)
  * [回路図(v1.1)](hardware/xiaogyan.v1.1.pdf)

* ソフトウェア
  * [サンプルコード](https://github.com/algyan/xiaogyan_examples)
  * [Arduino用ライブラリ](https://github.com/algyan/xiaogyan_arduino)

## EAGLE design hardware/xiaogyan.v1.1.brd

Parts:
C1: 0.1u; C0603
C2: 1u; C0603
C3, C4, C5: 10u; C0603
C6: 1000p; C0805
C7, C8: DNP; C0603
CN1: 4P-2.0; HW4-2.0
CN2: PINHD-1X1; 1X01
JP1, JP3: JUMPER-SMT_3_NO_SILK; SMT-JUMPER_3_NO_SILK
JP2: JUMPER-SMT_2_NC_TRACE_SILK; SMT-JUMPER_2_NC_TRACE_SILK
R1, R2, R3, R4, R5, R6, R7: 10K; R0603
R8, R9: 0; R0603
R10, R11, R12, R13, R14, R15, R16: DNP; R0603
U1: XIAO ESP32C3; SEEEDUINOXIAO
U2: TM1640
U3: LTP-12188M-08; LTP-12188M
U4: NJM2113D; DIL08
U5: NJM2113M; SO08
U6: UGSM23A
U7: EC12PLRVF
U8: EC12E(Panel); EC12E_PANEL
U9, U10: TVGP01-G73BB
U11: 10K; 3386K
U12: 10K; 3386T
U13: DNP; LED5MM

Connections:
3V3: C4.1, C5.1, CN1.3, JP1.1, JP2.2, R1.2, R2.2, R10.2, R11.2, R13.2, R14.2, R15.2, R16.2, U4.6 (VCC), U5.6 (VCC), U7.LED+, U13.A
5V: JP1.3, U1.14 (5V)
A-BTN: R13.1, U1.10 (D9/A9/MISO), U9.3 (1), U9.4 (1)
B-BTN: R14.1, U1.8 (D7/A7/RX), U10.3 (1), U10.4 (1)
COL1A: U2.19 (GRID2), U3.23 (COL1A)
COL1B: U2.18 (GRID1), U3.24 (COL1B)
COL2A: U2.21 (GRID4), U3.20 (COL2A)
COL2B: U2.20 (GRID3), U3.21 (COL2B)
COL3A: U2.23 (GRID6), U3.17 (COL3A)
COL3B: U2.22 (GRID5), U3.18 (COL3B)
COL4A: U2.24 (GRID7), U3.14 (COL4A)
COL4B: U2.5 (GRID16), U3.15 (COL4B)
COL5A: U2.1 (GRID12), U3.2 (COL5A)
COL5B: U2.28 (GRID11), U3.1 (COL5B)
COL6A: U2.2 (GRID13), U3.5 (COL6A)
COL6B: U2.27 (GRID10), U3.4 (COL6B)
COL7A: U2.3 (GRID14), U3.8 (COL7A)
COL7B: U2.26 (GRID9), U3.7 (COL7B)
COL8A: U2.4 (GRID15), U3.11 (COL8A)
COL8B: U2.25 (GRID8), U3.10 (COL8B)
DIN: R1.1, U1.11 (D10/A10/MOSI), U2.7 (DIN)
ENC-A: C7.1, R8.2, U1.2 (D1/A1)
ENC-B: C8.1, R9.2, U1.3 (D2/A2)
GND: C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, CN1.4, U1.13 (GND), U2.6 (VSS), U4.7 (GND), U5.7 (GND), U7.C, U8.C, U9.1 (0), U9.2 (0), U10.1 (0), U10.2 (0), U11.1, U12.3
LED: R5.1, R6.1, R12.1, U1.7 (D6/A6/TX)
unnamed: R3.1, U4.5 (VOUT1), U5.5 (VOUT1), U6.- (2)
unnamed: R3.2, R4.1, U4.4 (-VIN), U5.4 (-VIN)
unnamed: U4.8 (VOUT2), U5.8 (VOUT2), U6.+ (1)
unnamed: C1.1, R4.2
unnamed: C2.1, U4.3 (+VIN), U5.3 (+VIN)
unnamed: R5.2, R6.2, U7.LED-
unnamed: R8.1, R10.1, U7.A, U8.A
unnamed: C1.2, U11.2, U12.2
unnamed: R9.1, R11.1, U7.B, U8.B
unnamed: C6.1, R7.1, U11.3, U12.1
unnamed: R12.2, U13.K (C)
unnamed: JP3.2, U1.4 (D3/A3)
unnamed: C3.1, JP1.2, U2.17 (VDD)
unnamed: JP2.1, U1.12 (3V3)
unnamed: CN2.1, JP3.1
ROW1: U2.15 (SEG7), U3.22 (ROW1)
ROW2: U2.14 (SEG6), U3.19 (ROW2)
ROW3: U2.16 (SEG8), U3.16 (ROW3)
ROW4: U2.13 (SEG5), U3.13 (ROW4)
ROW5: U2.9 (SEG1), U3.3 (ROW5)
ROW6: U2.10 (SEG2), U3.6 (ROW6)
ROW7: U2.11 (SEG3), U3.9 (ROW7)
ROW8: U2.12 (SEG4), U3.12 (ROW8)
SCL: CN1.1, R15.1, U1.6 (D5/A5/SCL)
SCLK: R2.1, U1.9 (D8/A8/SCK), U2.8 (SCLK)
SDA: CN1.2, R16.1, U1.5 (D4/A4/SDA)
SPEAKER: R7.2, U1.1 (D0/A0/DAC)
SPEAKER-ENABLE: JP3.3, U4.1 (CD), U5.1 (CD)

Notes on the sheet:
Grove-I2C
SCL
SDA
VCC
GND
D9 ... アクティブLOWの入力（BOOTボタンに接続されている）
D6 ... 出力（リセット直後HIGH）
電流測定用
アナログ入力
U2電源電圧切替
D8 ... プルアップ必須

Board: 2 copper layers, 142.0 x 55.0 mm, 42 parts (3 on the bottom side), 53 nets.

## EAGLE design hardware/algyan_8th.es2mod.brd

Parts:
C1, C6, C9: 10u; C0603
C2: 0.1u; C0603
C3: DNP; C0805
C5: 1u; C0603
C7, C8: DNP; C0603
CN1: 4P-2.0; HW4-2.0
JP1: JUMPER-SMT_3_NO_SILK; SMT-JUMPER_3_NO_SILK
JP2: JUMPER-SMT_3_1-NC_TRACE_SILK; SMT-JUMPER_3_1-NC_TRACE_SILK
JP3: PINHD-1X1; 1X01
JP5: JUMPER-SMT_2_NC_TRACE_SILK; SMT-JUMPER_2_NC_TRACE_SILK
LED1: LED5MM
R1, R2: 100K; R0603
R3, R4, R12: 10K; R0603
R5, R6, R10, R11, R17: 0; R0603
R7: R-EU_R0603; R0603
R8, R9, R13, R14, R15, R16: DNP; R0603
U1: XIAO ESP32C3; SEEEDUINOXIAO
U2: TM1640
U3: NJM2113M; SO08
U4: LTP-12188M-08; LTP-12188M
U5: NJM2113D; DIL08
U6: UGSM23A
U7: EC12PLRVF
U8, U9: TVGP01-G73BB
U10: EC12E(Panel); EC12E_PANEL
VR1: 10K; 3386K
VR2: 10K; 3386T

Connections:
3V3: C6.1, C9.1, CN1.3, JP1.1, JP5.2, LED1.A, R1.2, R2.2, R8.2, R9.2, R13.2, R14.2, R15.2, R16.2, U3.6 (VCC), U5.6 (VCC), U7.LED+
5V: JP1.3, U1.14 (5V)
A-BTN: R13.1, U1.10 (D9/A9/MISO), U8.3 (1), U8.4 (1)
B-BTN: R14.1, U1.8 (D7/A7/RX), U9.3 (1), U9.4 (1)
COL1A: U2.19 (GRID2), U4.23 (COL1A)
COL1B: U2.18 (GRID1), U4.24 (COL1B)
COL2A: U2.21 (GRID4), U4.20 (COL2A)
COL2B: U2.20 (GRID3), U4.21 (COL2B)
COL3A: U2.23 (GRID6), U4.17 (COL3A)
COL3B: U2.22 (GRID5), U4.18 (COL3B)
COL4A: U2.24 (GRID7), U4.14 (COL4A)
COL4B: U2.5 (GRID16), U4.15 (COL4B)
COL5A: U2.1 (GRID12), U4.2 (COL5A)
COL5B: U2.28 (GRID11), U4.1 (COL5B)
COL6A: U2.2 (GRID13), U4.5 (COL6A)
COL6B: U2.27 (GRID10), U4.4 (COL6B)
COL7A: U2.3 (GRID14), U4.8 (COL7A)
COL7B: U2.26 (GRID9), U4.7 (COL7B)
COL8A: U2.4 (GRID15), U4.11 (COL8A)
COL8B: U2.25 (GRID8), U4.10 (COL8B)
DIN: R1.1, U1.11 (D10/A10/MOSI), U2.7 (DIN)
ENC-A: C7.1, R10.2, U1.2 (D1/A1)
ENC-B: C8.1, R11.2, U1.3 (D2/A2)
GND: C1.2, C3.2, C5.2, C6.2, C7.2, C8.2, C9.2, CN1.4, U1.13 (GND), U2.6 (VSS), U3.7 (GND), U5.7 (GND), U7.C, U8.1 (0), U8.2 (0), U9.1 (0), U9.2 (0), U10.C, VR1.1, VR2.1
LED: R7.1, R12.1, U1.7 (D6/A6/TX)
unnamed: R3.1, U3.5 (VOUT1), U5.5 (VOUT1), U6.- (2)
unnamed: R3.2, R4.1, U3.4 (-VIN), U5.4 (-VIN)
unnamed: U3.8 (VOUT2), U5.8 (VOUT2), U6.+ (1)
unnamed: C2.1, R4.2
unnamed: C5.1, U3.3 (+VIN), U5.3 (+VIN)
unnamed: R7.2, U7.LED-
unnamed: R8.1, R10.1, U7.A, U10.A
unnamed: C2.2, VR1.2, VR2.2
unnamed: R9.1, R11.1, U7.B, U10.B
unnamed: C3.1, R5.1, VR1.3, VR2.3
unnamed: LED1.K (C), R12.2
unnamed: JP2.2, U1.4 (D3/A3)
unnamed: C1.1, JP1.2, U2.17 (VDD)
unnamed: JP5.1, U1.12 (3V3)
unnamed: JP2.1, JP3.1
unnamed: CN1.1, R6.1, R15.1
unnamed: CN1.2, R16.1, R17.1
ROW1: U2.15 (SEG7), U4.22 (ROW1)
ROW2: U2.14 (SEG6), U4.19 (ROW2)
ROW3: U2.16 (SEG8), U4.16 (ROW3)
ROW4: U2.13 (SEG5), U4.13 (ROW4)
ROW5: U2.9 (SEG1), U4.3 (ROW5)
ROW6: U2.10 (SEG2), U4.6 (ROW6)
ROW7: U2.11 (SEG3), U4.9 (ROW7)
ROW8: U2.12 (SEG4), U4.12 (ROW8)
SCL: R6.2, U1.6 (D5/A5/SCL)
SCLK: R2.1, U1.9 (D8/A8/SCK), U2.8 (SCLK)
SDA: R17.2, U1.5 (D4/A4/SDA)
SPEAKER: R5.2, U1.1 (D0/A0/DAC)
SPEAKER-ENABLE: JP2.3, U3.1 (CD), U5.1 (CD)

Notes on the sheet:
ISU1-I2C
SCL
SDA
VCC
GND
D9はBOOTボタンに接続されている（アクティブLOW）
D6はリセット直後HIGH出力
電流測定用
アナログ入力
U2電源電圧切替
変更点
SPEAKER-ENABLEとLEDのピン割当を入れ替え
SELECT-BTNとESCAPE-BTNの信号名を変更

Board: 2 copper layers, 142.0 x 55.0 mm, 43 parts (3 on the bottom side), 55 nets.

## EAGLE design hardware/algyan_8th.es.brd

Parts:
C1, C6, C9: 10u; C0805
C2: 0.1u; C0603
C3, C4: DNP; C0805
C5: 1u; C0805
C7, C8: DNP; C0603
CN1: 4P-2.0; HW4-2.0
JP1: JUMPER-SMT_3_NO_SILK; SMT-JUMPER_3_NO_SILK
JP2, JP3: JUMPER-SMT_2_NO_SILK; SMT-JUMPER_2_NO_SILK
JP4: CONN_02; 1X02
LED1: LED5MM
R1, R2: 100K; R0603
R3, R4, R12: 10K; R0603
R5, R10, R11: 0; R0603
R6, R8, R9, R13, R14: DNP; R0603
R7: R-EU_R0603; R0603
U1: XIAO ESP32C3; SEEEDUINOXIAO
U2: TM1640
U3: OSL641501-AY; OSL641501
U4: LTP-12188M-08; LTP-12188M
U5: NJM2113D; DIL08
U6: UGSM23A
U7: EC12PLRVF
U8, U9: TVGP01-G73BB
VR1: 10K; 3386K
VR2: 10K; 3386T

Connections:
3V3: C6.1, C9.1, CN1.3, JP1.1, JP4.1, R1.2, R2.2, R8.2, R9.2, U5.6 (VCC), U8.3 (1), U8.4 (1), U9.3 (1), U9.4 (1)
5V: JP1.3, U1.14 (5V)
COL1A: U2.19 (GRID2), U3.9 (ROW1), U4.23 (COL1A)
COL1B: U2.18 (GRID1), U4.24 (COL1B)
COL2A: U2.21 (GRID4), U3.14 (ROW2), U4.20 (COL2A)
COL2B: U2.20 (GRID3), U4.21 (COL2B)
COL3A: U2.23 (GRID6), U3.8 (ROW3), U4.17 (COL3A)
COL3B: U2.22 (GRID5), U4.18 (COL3B)
COL4A: U2.24 (GRID7), U3.12 (ROW4), U4.14 (COL4A)
COL4B: U2.5 (GRID16), U4.15 (COL4B)
COL5A: U2.1 (GRID12), U3.1 (ROW5), U4.2 (COL5A)
COL5B: U2.28 (GRID11), U4.1 (COL5B)
COL6A: U2.2 (GRID13), U3.7 (ROW6), U4.5 (COL6A)
COL6B: U2.27 (GRID10), U4.4 (COL6B)
COL7A: U2.3 (GRID14), U3.2 (ROW7), U4.8 (COL7A)
COL7B: U2.26 (GRID9), U4.7 (COL7B)
COL8A: U2.4 (GRID15), U3.5 (ROW8), U4.11 (COL8A)
COL8B: U2.25 (GRID8), U4.10 (COL8B)
DIN: R1.1, U1.11 (D10/A10/MOSI), U2.7 (DIN)
ENC-A: C7.1, R10.2, U1.2 (D1/A1)
ENC-B: C8.1, R11.2, U1.3 (D2/A2)
ENC-LED: JP2.1, U7.LED+
ESC-BTN: R14.2, U1.10 (D9/A9/MISO), U9.1 (0), U9.2 (0)
GND: C1.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, CN1.4, R6.1, R7.1, R12.1, R13.1, R14.1, U1.13 (GND), U2.6 (VSS), U5.7 (GND), U7.C, VR1.1, VR2.1
LED: JP3.1, LED1.A
unnamed: R3.1, U5.5 (VOUT1), U6.- (2)
unnamed: R3.2, R4.1, U5.4 (-VIN)
unnamed: U5.8 (VOUT2), U6.+ (1)
unnamed: C2.1, R4.2
unnamed: C5.1, U5.3 (+VIN)
unnamed: C4.1, U5.2 (VREF)
unnamed: R8.1, R10.1, U7.A
unnamed: C2.2, VR1.2, VR2.2
unnamed: R9.1, R11.1, U7.B
unnamed: C3.1, R5.1, VR1.3, VR2.3
unnamed: LED1.K (C), R12.2
unnamed: JP2.2, JP3.2, U1.7 (D6/A6/TX)
unnamed: C1.1, JP1.2, U2.17 (VDD)
unnamed: R7.2, U7.LED-
unnamed: JP4.2, U1.12 (3V3)
ROW1: U2.15 (SEG7), U3.13 (COL1), U4.22 (ROW1)
ROW2: U2.14 (SEG6), U3.3 (COL2), U4.19 (ROW2)
ROW3: U2.16 (SEG8), U3.4 (COL3), U4.16 (ROW3)
ROW4: U2.13 (SEG5), U3.10 (COL4), U4.13 (ROW4)
ROW5: U2.9 (SEG1), U3.6 (COL5), U4.3 (ROW5)
ROW6: U2.10 (SEG2), U3.11 (COL6), U4.6 (ROW6)
ROW7: U2.11 (SEG3), U3.15 (COL7), U4.9 (ROW7)
ROW8: U2.12 (SEG4), U3.16 (COL8), U4.12 (ROW8)
SCL: CN1.1, U1.6 (D5/A5/SCL)
SCLK: R2.1, U1.9 (D8/A8/SCK), U2.8 (SCLK)
SDA: CN1.2, U1.5 (D4/A4/SDA)
SEL-BTN: R13.2, U1.8 (D7/A7/RX), U8.1 (0), U8.2 (0)
SPEAKER: R5.2, U1.1 (D0/A0/DAC)
SPEAKER-ENABLE: R6.2, U1.4 (D3/A3), U5.1 (CD)

Notes on the sheet:
ISU1-I2C
SCL
SDA
VCC
GND
D9はBOOTボタンに接続されている（アクティブLOW）
D6はリセット直後HIGH出力

Board: 2 copper layers, 130.0 x 80.0 mm, 40 parts (0 on the bottom side), 54 nets.

## Commit log

2022-11-24 README更新
2022-12-05 LedMatrixTM1640追加
2022-12-05 LEDマトリックスを2色のものに変更
2022-12-06 Speaker追加
2022-12-12 ES基板のEAGLEファイルを追加
2022-12-18 ES基板の回路図PDFを追加
2022-12-19 LedMatrixTM1640を改修
2022-12-20 Speaker2追加
2022-12-20 不要なファイルを削除
2022-12-21 Speaker2を改修
2022-12-21 Encoder追加
2022-12-25 ES基板の結線に変更
2022-12-26 ES基板の回路図に部品の値を記入
2022-12-29 ButtonAndLed追加(WIP)
2023-01-01 ButtonAndLedを改修
2023-01-01 GroveAccelerometer16G追加
2023-01-07 ES2基板のEAGLEファイルと回路図PDFを追加
2023-02-02 ES2基板のEAGLEファイルと回路図PDFを修正
2023-02-02 ES2基板のBOMを追加
2023-02-10 Fix #25
2023-02-16 ES2MOD基板に変更
2023-02-16 サンプルコードを整理
2023-02-16 AnalogIn追加
2023-02-16 ES3基板のEAGLEファイルと回路図PDFを追加
2023-02-17 コードを分離
2023-02-19 "XIAOGYAN"に名前変更
2023-02-19 ライブラリを別リポジトリへ
2023-03-06 ES3基板のBOMを追加
2023-03-20 v1部品番号を記入
2023-03-27 xiaogyan.v1を追加
2023-04-08 部品を追加
2023-04-16 Create README.md
    基板の組立手順を作成．
2023-04-16 組立画像のアップロード
    まずは，基板と実装指示分のみ
2023-04-16 画像の埋め込みテスト
2023-04-16 画像の余白のトリミング
    白い余白付きの画像となってしまっていた為，トリミングして再アップ
2023-04-16 組立手順用の画像アップロード
2023-04-26 R7とC6を変更
2023-05-05 章立てを変更
2023-05-05 部品貼付台紙を追加
2023-05-05 ディレクトリ変更
2023-05-09 部品手配マニュアルを追加
2023-05-16 XIAOGYAN写真を差し替え
2023-05-17 動作確認マニュアルを追加
2023-05-17 esptoolのPythonバージョンを変更
2023-05-17 しおりを追加
2023-05-17 画像サイズを変更
2023-05-22 挿入実装品の組立用画像のアップロード
    オペアンプ，VR，ボタン，スピーカ，LEDマトリクス，エンコーダ
2023-05-22 挿入実装品の画像の更新
    Groveコネクタ，マイコン，ロータリエンコーダ
2023-05-22 C6とR7を実装に伴う変更
    1000pFは手元に無いため，図のみ変更で対応
2023-05-22 C6とR7を実装に伴う変更
    組立マニュアル側も変更
2023-05-22 R7とC6を変更(部品貼付台紙)
    部品貼付台紙のpdfを更新．合わせて原本であるxlsxを追加
2023-05-22 JP3 - SPENは無し
2023-05-23 C6 fixed
    C6を図示すべきところを誤ってC7を図示していた為
2023-05-23 Update README.md
    ・C6のリスト番号が誤っていた為に修正
    ・3.動作確認 を 3.チェック に変更
2023-05-24 typo
2023-05-28 guidebook更新
2023-05-29 fix link to parts list file (xiaogyan.v1.xlsx)
2023-06-11 チップコンデンサ(1000pF)のはんだ付け誤記修正
    リスト⑯の10uFとなっていたので修正
2023-06-12 Groveコネクタの取り付け画像の修正
    本来，L字コネクタのところI字のコネクタの写真としてしまっていた為に修正
    https://github.com/algyan/XIAOGYAN/issues/61
2023-06-12 Update README.md
    はんだ付けの順序の入替による更新
    https://github.com/algyan/XIAOGYAN/issues/57
2023-06-14 img45.PNGのC1とC2の青枠の漏れ修正
    https://github.com/algyan/XIAOGYAN/issues/53#issuecomment-1590338423
2023-06-14 Fix #64
2023-06-20 ソフトウェア開発マニュアルを追加
2023-06-20 「ファームウェア」を「ソフトウェア」に変更
2023-06-20 画像ファイルの拡張子を訂正
2023-06-20 Close #62
2023-06-20 部品手配マニュアルに機材マニュアルへのリンクを追加
2023-09-06 PCB v1.1を追加
2023-11-30 Fix #76

Notices in the files:
parts and their libraries:
SparkFun-Jumpers: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
